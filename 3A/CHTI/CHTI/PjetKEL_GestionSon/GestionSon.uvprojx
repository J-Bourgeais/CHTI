# Keil uVision project GestionSon.uvprojx, settings and files
target CibleSondeKEIL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GestionSon +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: .\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Principal
    ./Principal/: principal.c
  group GestionSon
    ./GestionSon/: GestionSon.s bruitverre.asm
  group Driver
    ./Driver/: DriverJeuLaser.lib ServiceJeuLaser.c
  group Sys
    ./System/: startup-rvds.s
  group ServiceDFT
    ./Service_DFT_float/: DFT.c
    ../Service_DFT_Fract/: CosSin_Fract_1_15.asm Signal_4_12.asm
target Simu (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: GestionSon +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: U:\3A\CHTI\CHTI\PjetKEL_GestionSon\Service_DFT_float;.\Driver
  asm include: U:\3A\CHTI\CHTI\PjetKEL_GestionSon\Driver\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
